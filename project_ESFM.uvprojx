# Keil uVision project project_ESFM.uvprojx, settings and files
target Non-distributed (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: project_ESFM
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --diag_error=223
  c include: .\Include;.\ioLibrary_Driver-master\Ethernet;.\ioLibrary_Driver-master\Ethernet\W5500
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Modules
    ./Source/: application.c controller.c peripherals.c app-client.c app-server.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L476RGTx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L476RGTx/STCubeGenerated/Inc/: stm32l4xx_it.h
  group Ethernet
    ./ioLibrary_Driver-master/Ethernet/: socket.c wizchip_conf.c
    ./ioLibrary_Driver-master/Ethernet/W5500/: w5500.c
target Client (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: Client
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: _ETHERNET_ENABLED _CLIENT_CONFIG
  c misc: --diag_error=223
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target Server (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: Server
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: _ETHERNET_ENABLED _SERVER_CONFIG
  c misc: --diag_error=223
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS:Keil RTX 4.82.0, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube HAL:Common 1.13.0, Device:STM32Cube HAL:Cortex 1.13.0, Device:STM32Cube HAL:DMA 1.13.0, Device:STM32Cube HAL:GPIO 1.13.0, Device:STM32Cube HAL:PWR 1.13.0, Device:STM32Cube HAL:RCC 1.13.0, Device:STM32Cube HAL:SPI 1.13.0, Device:STM32Cube HAL:TIM 1.13.0, Device:STM32Cube HAL:UART 1.13.0, Device:STM32Cube HAL:USART 1.13.0, Device:Startup 1.3.1
